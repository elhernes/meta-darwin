SRC_URI_append_darwin = " file://darwinfix.patch "

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
