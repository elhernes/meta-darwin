EXTRA_OECONF_append_darwin = " ac_cv_tls=none"
