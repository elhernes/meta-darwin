#Remove -rpath-link and -rpath
LDFLAGS_darwinsdk = "${BUILDSDK_LDFLAGS} -L${libdir}/.."


