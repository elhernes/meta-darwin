PACKAGECONFIG:darwin19:class-nativesdk = "update-alternatives"

RDEPENDS:opkg-utils:class-nativesdk = ""
