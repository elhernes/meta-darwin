PN = "clang-crosssdk-${SDK_SYS}"
