CPPFLAGS:append:class-nativesdk:darwin19 = " \
    -I${STAGING_INCDIR} \
"
