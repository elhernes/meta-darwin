EXTRA_OECONF_darwin = "--enable-included-printf=yes ${CORECONF}"
FILES_${PN}_append_darwin = " ${libdir}/charset.alias"
