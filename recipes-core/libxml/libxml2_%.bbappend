PACKAGECONFIG_remove_class-nativesdk_darwin9 = "python"
