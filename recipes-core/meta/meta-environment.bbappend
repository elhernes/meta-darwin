EXCLUDE_FROM_SHLIBS = "1"
