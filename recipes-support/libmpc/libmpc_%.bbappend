EXTRA_OECONF_append_darwin19 = " --with-gmp=${STAGING_EXECPREFIXDIR}"
