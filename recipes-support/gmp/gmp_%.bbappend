FILES_${PN}_append_darwin9 = " ${libdir}/*.dylib"
