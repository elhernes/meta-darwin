EXTRA_OECONF_append_darwin9 = " --with-gmp=${STAGING_EXECPREFIXDIR}"
