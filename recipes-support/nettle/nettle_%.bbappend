
EXTRA_OECONF:append:darwin21 = " --enable-mini-gmp"
INSANE_SKIP:append:darwin21 = " buildpaths"
